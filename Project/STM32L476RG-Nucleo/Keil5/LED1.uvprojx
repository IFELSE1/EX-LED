# Keil uVision project LED1.uvprojx, settings and files
target LED1 (ARM-ADS)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO
  c include: ..\..\..\Source\Common;..\..\..\Source\Device\LED;..\..\..\Source\Platform;..\..\..\Source\Platform\Board;..\..\..\Source\Platform\Board\STM32L476RG-Nucleo;..\..\..\Source\Platform\Board\STM32L476RG-Nucleo\BSP;..\..\..\Source\Platform\CPU;..\..\..\Source\Platform\CPU\STM32L476RG;..\..\..\Source\Platform\CPU\STM32L476RG\Lib;..\..\..\Source\Platform\CPU\STM32L476RG\Lib\STM32L4xx_HAL_Driver;..\..\..\Source\Platform\CPU\STM32L476RG\Lib\STM32L4xx_HAL_Driver\Inc;..\..\..\Source\Platform\CPU\STM32L476RG\Lib\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\Source\User;..\..\..\Source\Platform\CPU\STM32L476RG\Core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Common
    ../../../Source/Common/: Common.c
  group Device
    ../../../Source/Device/LED/: led.c
  group Lib
    ../../../Source/Platform/CPU/STM32L476RG/Lib/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
    ../../../Source/Platform/CPU/STM32L476RG/Lib/: system_stm32l4xx.c
  group User
    ../../../Source/User/: main.c
  group Core
    ../../../Source/Platform/CPU/STM32L476RG/: startup_stm32l476xx.s
  group Platform
    ../../../Source/Platform/Board/STM32L476RG-Nucleo/BSP/: stm32l4xx_nucleo.c
    ../../../Source/Platform/CPU/STM32L476RG/: stm32l4xx_it.c stm32l476rg.c
    ../../../Source/Platform/: clock.c
